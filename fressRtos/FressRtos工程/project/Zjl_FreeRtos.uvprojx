# Keil uVision project Zjl_FreeRtos.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Zjl_FreeRtos
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\freertos\include;..\freertos\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
  group user
    ../user/: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.3
